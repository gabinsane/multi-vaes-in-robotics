Commit message: iros update

File: models/lanro_gym/objects_urdfs/soap.urdf (robot description, URDF)
Before this commit: robot model.urdf, 1 links, 0 joints
Links:
- link baseLink: mass 0.1 -> 1.0
